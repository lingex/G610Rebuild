# Keil uVision project G610Rebuild.uvprojx, settings and files
target G610Rebuild (6140000::V6.14::ARMCLANG)
  device: STM32L100R8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: G610Rebuild +hex
  AfterMake: ../dfutool/hex2dfu -h $L/G610Rebuild.hex -o g610App.dfu
  AfterMake: fromelf --bin -o g610App.bin "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L100xB
  c include: ../Inc;                           ../Drivers/STM32L1xx_HAL_Driver/Inc;                           ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;                           ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                           ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;                           ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;                           ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l100xb.s
  group Application/User
    ../Src/: state_led.c keyboard.c matrix_led.c usbd_hid.c ztask.c main.c usb_device.c usbd_conf.c usbd_desc.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_ll_usb.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 5.4.0
